# Keil uVision project project.uvprojx, settings and files
target fram_prog (6180000::V6.18::ARMCLANG)
  device: VA416xx Vorago
  pack: Vorago.VA416xx.1.0.4
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: VA416_EBIBOOT_FRAM_256KB +hex
  AfterMake: cmd.exe /C copy "Objects\%L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=5
  c include: \
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: .\target.lin
  link misc: --diag_suppress L6305
  group program functions
    ./: flash_os.h flash_prg.c
  group device description
    ./: flash_dev.c
