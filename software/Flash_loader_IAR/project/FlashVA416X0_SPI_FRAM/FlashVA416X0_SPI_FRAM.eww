<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\FlashVA416X0_SPI_FRAM.ewp</path>
    </project>
    <batchBuild />
</workspace>
