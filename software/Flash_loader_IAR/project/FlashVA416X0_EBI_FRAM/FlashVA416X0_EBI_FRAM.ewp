# IAR project FlashVA416X0_EBI_FRAM.ewp, settings and files
configuration FlashVA416X0_EBI_FRAM (ARM, debug)
  General.OGChipSelectEditMenu: VA10820 Vorago VA10820
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\src\flashloader\framework2\; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FlashVA416X0_EBI_FRAM.srec
  ILINK.IlinkOutputFile: FlashVA416X0_EBI_FRAM.out
  ILINK.IlinkIcfFile: FlashVA416X0.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: FlashVA416X0.s FlashVA416X0_EBI_FRAM.c readme.txt
  group Framework
    $EW_DIR$/arm/src/flashloader/framework2/: flash_loader.c flash_loader_asm.s
