# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\common\mcu\hdr; ..\..\common\drivers\hdr; ..\..\common\BSP\evk\hdr; ..\..\common\utils\hdr; ..\..\apps\freertos_blinky\hdr; ..\..\freeRTOS\source\include; ..\..\freeRTOS\source\config; ..\..\freeRTOS\source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\freeRTOS\source\config; ..\..\common\mcu\hdr
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group common/drivers/src
    ../../common/drivers/src/: va416xx_debug.c va416xx_hal.c va416xx_hal_clkgen.c va416xx_hal_ioconfig.c va416xx_hal_irqrouter.c va416xx_hal_timer.c
  group common/mcu/src
    ../../common/mcu/src/: system_va416xx.c
  group common/utils/src
    ../../common/utils/src/: segger_rtt.c segger_rtt_printf.c spi_fram.c
  group freeRTOS/source
    ../../freeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS/source/portable/IAR/ARM_CM4F
    ../../freeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group freeRTOS/source/portable/MemMang
    ../../freeRTOS/Source/portable/MemMang/: heap_4.c
  group hdr
    ../../apps/freertos_blinky/hdr/: board.h hal_config.h uart.h
  group src
    ../../apps/freertos_blinky/src/: board.c freertos.c hardFault_handler.c main.c startup_IAR_va416xx.s uart.c
