# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\common\mcu\hdr; ..\..\common\drivers\hdr; ..\..\common\BSP\evk\hdr; ..\hdr
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: project.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\common\mcu\hdr; ..\..\common\drivers\hdr; ..\..\common\utils\hdr; ..\..\common\BSP\evk\hdr; ..\..\apps\bootloader\hdr
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: project.out
  group common/drivers/src
    ../../common/drivers/src/: va416xx_hal.c va416xx_hal_clkgen.c va416xx_hal_ioconfig.c va416xx_hal_irqrouter.c
  group common/mcu/src
    ../../common/mcu/src/: system_va416xx.c
  group common/utils/src
    ../../common/utils/src/: spi_fram.c
  group hdr
    ../../apps/bootloader/hdr/: board.h bootloader.h crc.h hal_config.h main.h memtest.h stdio_remap.h uart.h xmodem.h
  group src
    ../../apps/bootloader/src/: board.c bootloader.c crc.c hardFault_handler.c main.c memtest.c startup_IAR_va416xx.s stdio_remap.c uart.c vectrst_IAR.s xmodem.c
