# IAR project VA416xx_EVK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: VA41620 Vorago VA41620
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\common\mcu\hdr; ..\..\common\drivers\hdr; ..\..\common\BSP\evk\hdr; ..\..\common\utils\hdr; ..\..\apps\demo\hdr
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: VA416xx_EVK.srec
  ILINK.IlinkOutputFile: VA416xx_EVK.out
  ILINK.IlinkIcfFile: VA416xx_EVK.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  group common/BSP/evk/src
    ../../common/BSP/evk/src/: i2c_adxl343.c i2c_lis2de12.c peb1_va416xx_evk.c
  group common/drivers/src
    ../../common/drivers/src/: va416xx_debug.c va416xx_hal.c va416xx_hal_adc.c va416xx_hal_canbus.c va416xx_hal_clkgen.c va416xx_hal_dac.c va416xx_hal_dma.c va416xx_hal_ethernet.c va416xx_hal_i2c.c va416xx_hal_ioconfig.c va416xx_hal_irqrouter.c va416xx_hal_spi.c va416xx_hal_timer.c va416xx_hal_uart.c
  group common/mcu/src
    ../../common/mcu/src/: system_va416xx.c
  group common/utils/src
    ../../common/utils/src/: circular_buffer.c dac_sine.c segger_rtt.c segger_rtt_printf.c spi_fram.c
  group hdr
    ../../apps/demo/hdr/: board.h can_test.h cmd_interface.h hal_config.h phy_test.h phytest_cfg.h
  group src
    ../../apps/demo/src/: board.c can_test.c cmd_interface.c hardFault_handler.c main.c phy_test.c startup_IAR_va416xx.s
