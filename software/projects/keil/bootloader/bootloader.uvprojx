# Keil uVision project bootloader.uvprojx, settings and files
target project (6180000::V6.18::ARMCLANG)
  device: VA416xx Vorago
  pack: Vorago.VA416xx.1.0.6
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lumicBootloader +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\apps\bootloader\hdr;..\..\common\mcu\hdr;..\..\common\drivers\hdr;..\..\common\utils\hdr
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x3ffe
  memory RVCT9: RAM 0x1fffd000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ../../apps/bootloader/src/: main.c bootloader.c memtest.c vectrst_Keil.s crc.c hardFault_handler.c stdio_remap.c uart.c xmodem.c board.c hardFault_handler_asm_keil.s startup_Keil_va416xx.s
  group common/mcu/src
    ../../common/mcu/src/: system_va416xx.c
  group common/drivers/src
    ../../common/drivers/src/: va416xx_hal.c va416xx_hal_clkgen.c va416xx_hal_ioconfig.c va416xx_hal_irqrouter.c
  group common/utils/src
    ../../common/utils/src/: spi_fram.c
