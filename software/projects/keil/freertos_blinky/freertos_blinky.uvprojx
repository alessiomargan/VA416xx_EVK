# Keil uVision project freertos_blinky.uvprojx, settings and files
target project (6180000::V6.18::ARMCLANG)
  device: VA416xx Vorago
  pack: Vorago.VA416xx.1.0.6
  cpu: IRAM(0x1FFF8000,0x8000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_blinky +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin #L --output $L@L.bin
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\..\apps\freertos_blinky\hdr;..\..\common\mcu\hdr;..\..\common\drivers\hdr;..\..\common\BSP\evk\hdr;..\..\common\utils\hdr;..\..\freeRTOS\source\include;..\..\freeRTOS\source\config;..\..\freeRTOS\source\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ../../apps/freertos_blinky/src/: main.c board.c uart.c hardFault_handler.c hardFault_handler_asm_keil.s startup_Keil_va416xx.s freertos.c
  group common/mcu/src
    ../../common/mcu/src/: system_va416xx.c
  group common/drivers/src
    ../../common/drivers/src/: va416xx_debug.c va416xx_hal.c va416xx_hal_clkgen.c va416xx_hal_ioconfig.c va416xx_hal_irqrouter.c va416xx_hal_timer.c
  group common/utils/src
    ../../common/utils/src/: segger_rtt.c segger_rtt_printf.c spi_fram.c
  group freeRTOS/source
    ../../freeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS/source/portable/GCC/ARM_CM4F
    ../../freeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group freeRTOS/source/portable/MemMang
    ../../freeRTOS/Source/portable/MemMang/: heap_4.c
